RDEPENDS_${PN} += " \
	u-boot-fus \
"
