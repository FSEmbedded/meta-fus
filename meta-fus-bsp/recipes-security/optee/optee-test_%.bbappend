COMPATIBLE_MACHINE = "(imx-nxp-bsp|imx-mainline-bsp)"
