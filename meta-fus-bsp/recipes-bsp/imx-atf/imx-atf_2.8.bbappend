# Copyright 2024 F&S Elektronik Systeme GmbH

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI[md5sum] = "fc5412a097bf597229beeac0295627ba"
SRC_URI += "file://0001-add-support-for-fsimx93.patch"


