ATF_SRC = "git://github.com/FSEmbedded/atf-fus;protocol=https"
SRC_URI = "${ATF_SRC};branch=${SRCBRANCH}"
SRCBRANCH = "atf-fus-2.14"
PV = "v2.14-fus1.0"
SRCREV = "ae00faf231460f7ea622c679bcaded398fc9a070"
