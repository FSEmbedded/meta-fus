# Copyright (C) 2026 F&S Elektronik Systeme GmbH
# Released under the MIT license (see COPYING.MIT for the terms)

require u-boot-fus.inc

LICENSE = "GPL-2.0-or-later"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "2026.04"
SRCBRANCH = "uboot-fus-2026.04"
# v2026.04-fus1.0
SRCREV = "75c46fd16154cc7ce7e7f27e1211bd546c4faeeb"
