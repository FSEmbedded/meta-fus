# Copyright (C) 2020 F&S Elektronik Systeme GmbH
# Released under the MIT license (see COPYING.MIT for the terms)

require u-boot-fus.inc

LICENSE = "GPL-2.0-or-later"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"

UBOOT_VERSION = "2021.04"
SRCBRANCH = "uboot-fus-2021.04"
SRCREV = "eacbdd5740ecff0ac48e988e0b016ee6ad601cb9"

CVE_STATUS[CVE-2024-57254] = "patched"
CVE_STATUS[CVE-2024-57255] = "patched"
CVE_STATUS[CVE-2024-57256] = "patched"
CVE_STATUS[CVE-2024-57257] = "patched"
CVE_STATUS[CVE-2024-57258] = "patched"
CVE_STATUS[CVE-2024-57259] = "patched"
CVE_STATUS[CVE-2022-30767] = "patched"
CVE_STATUS[CVE-2022-34835] = "patched"
CVE_STATUS[CVE-2022-33103] = "patched"
CVE_STATUS[CVE-2022-33967] = "patched"
CVE_STATUS[CVE-2021-27097] = "patched"
CVE_STATUS[CVE-2021-27138] = "patched"
CVE_STATUS[CVE-2022-2347]  = "patched"
CVE_STATUS[CVE-2026-33243] = "patched"
CVE_STATUS[CVE-2024-42040] = "patched"


