ATF_SRC = "git://github.com/FSEmbedded/atf-fus;protocol=https"
SRC_URI = "${ATF_SRC};branch=${SRCBRANCH}"
SRCBRANCH = "master"
PV = "v2.10-fus1.5"
SRCREV = "8b9500f4a906b12e92db758106d1bff56f62d8b3"
