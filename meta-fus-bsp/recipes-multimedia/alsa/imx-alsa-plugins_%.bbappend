# Copyright (C) 2024 F&S Elektronik Systeme GmbH
# Released under the MIT license (see COPYING.MIT for the terms)
DESCRIPTION = "F&S standard image"
LICENSE = "MIT"

# disable debug builds to handle QA issue waring
DEBUG_BUILD = "0"
INHIBIT_PACKAGE_DEBUG_SPLIT = "1"
