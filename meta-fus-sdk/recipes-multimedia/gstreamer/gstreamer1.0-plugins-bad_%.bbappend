# Add VPU support for mainline bsp. In future releases, this should be
# part of the v4l2 plugins-good
PACKAGECONFIG:append:mx8mp-mainline-bsp = " v4l2codecs"

