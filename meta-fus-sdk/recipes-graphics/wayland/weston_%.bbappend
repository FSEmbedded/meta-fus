# Add rdp backend for remote desktop support
DEPENDS:append = " freerdp"
PACKAGECONFIG:append = " rdp"
