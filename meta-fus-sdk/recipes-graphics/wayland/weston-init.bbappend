# Add rdp backend for remote desktop support
PACKAGECONFIG:append = " rdp"
